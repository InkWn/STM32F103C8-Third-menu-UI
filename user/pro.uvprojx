# Keil uVision project pro.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pro +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\hardware\bsp;..\hardware\bus;..\hardware\device\led;..\hardware\device\oled;..\hardware\device\button;..\system\core;..\system\delay;..\system\nvic;..\system\sfrdef;..\system\sys;..\system\typedef;..\ui;..\ui\pages
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./: main.c startup_stm32f103xb.s
  group ui
    ../ui/: iwidget.c menuMgr.c pageMgr.c
  group pages
    ../ui/pages/: page_main.c page_menu.c page_time.c
  group hardware
    ../hardware/bus/: i2c.c spi.c
    ../hardware/device/button/: button.c
    ../hardware/bsp/: gpio.c
    ../hardware/device/led/: led.c
    ../hardware/device/oled/: oled.c Rstring.c
  group system
    ../system/core/: var.c
    ../system/delay/: delay.c
    ../system/nvic/: nvic.c
    ../system/sys/: rcc.c sys.c
